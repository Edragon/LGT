<workspace>
  <project>
    <path>$WS_DIR$\adcserial.ewp</path>
  </project>
</workspace>
