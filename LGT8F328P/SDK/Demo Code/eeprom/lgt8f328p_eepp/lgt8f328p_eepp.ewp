# IAR project lgt8f328p_eepp.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x80
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m328p ATA6614Q (ATmega328P)
  ICCAVR.newCCIncludePaths: .\Drivers\Includes\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm328p.xcl
  XLINK.XExtraOptions: -Oraw-binary,(CODE)=.bin; -Ointel-extended,(CODE)=.hex; -Ointel-extended,(XDATA)=.eep
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XExtraOptions: -Oraw-binary,(CODE)=.bin; -Ointel-extended,(XDATA)=.eep
  group (top)
    Drivers/Sources/: DrvEEPROM.c DrvMISC.c DrvSYS.c DrvUSART.c
    ./: init_auto.c main.c
