<workspace>
  <project>
    <path>$WS_DIR$\lgt8f328p_eepp.ewp</path>
  </project>
</workspace>
