# IAR project Backup of adcserial.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x80
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: .\Drivers\Includes\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm328p.xcl
  XLINK.XExtraOptions: -Oraw-binary,(CODE)=.bin; -Ointel-extended,(CODE)=.hex; -Ointel-extended,(XDATA)=.eep
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  XLINK.XExtraOptions: -Oraw-binary,(CODE)=.bin; -Ointel-extended,(XDATA)=.eep
  group (top)
    ./Drivers/Sources/: DrvMISC.c DrvSYS.c DrvUSART.c DrvADC.c
    ./: init_auto.c main.c
